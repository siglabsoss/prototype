<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>r01_feedback_port</value></param>
<param><key>value</key><value>1300</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>r0_rx_port</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>1235</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>r0_tx_port</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>1236</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>r1_tx_port</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>1238</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>all_rx_gain</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>all_tx_gain</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>udp_payload_size</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>1024*30</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>operator_ip</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>"127.0.0.1"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_freq</value></param>
<param><key>value</key><value>910e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1E8/512</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>r1_rx_port</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>1237</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1_0</value></param>
<param><key>note</key><value>Radio at .201</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>Radio at .200</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1_2</value></param>
<param><key>note</key><value>Both Radios</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1_1_1_0</value></param>
<param><key>note</key><value>Feedback</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>v_scale</key><value>0.5</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0.007</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>addr=192.168.1.202</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>samp_freq</value></param>
<param><key>gain0</key><value>all_tx_gain</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/ubuntu/prototype/simulink/r2_tx_pipe</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1_1</value></param>
<param><key>note</key><value>Radio at .202</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>addr=192.168.1.202</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>samp_freq</value></param>
<param><key>gain0</key><value>all_rx_gain</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/ubuntu/prototype/simulink/r2_rx_pipe</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>append</key><value>True</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>v_scale</key><value>0.5/8</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0.007</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0</value></param>
<param><key>type</key><value>fir_filter_ccc</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>20</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>low_cutoff_freq</key><value>-11E3</value></param>
<param><key>high_cutoff_freq</key><value>-9E3</value></param>
<param><key>width</key><value>500</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0_1_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>v_scale</key><value>0.5/8</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0.007</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>signal_up_mix</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>signal_up_mix</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>10E3</value></param>
<param><key>min</key><value>10E3-200</value></param>
<param><key>max</key><value>10E3+10</value></param>
<param><key>num_steps</key><value>200</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>band_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>wxgui_scopesink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_1</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>wxgui_scopesink2_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>wxgui_scopesink2_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>wxgui_fftsink2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
