<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_freq</value></param>
<param><key>value</key><value>910.25e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1E8/512</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>udp_payload_size</value></param>
<param><key>value</key><value>1024*30</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>operator_ip</value></param>
<param><key>value</key><value>"127.0.0.1"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>r1_tx_port</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>1238</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>all_tx_gain</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>r0_tx_port</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>1236</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>r0_rx_port</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>1235</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>r1_rx_port</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>1237</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>r01_feedback_port</value></param>
<param><key>value</key><value>1300</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>all_rx_gain</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1_0</value></param>
<param><key>note</key><value>Radio at .201</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>Radio at .200</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1_2</value></param>
<param><key>note</key><value>Both Radios</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1_1_1_0</value></param>
<param><key>note</key><value>Feedback</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1_1_2_0</value></param>
<param><key>note</key><value>TX Magic</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1_1_2</value></param>
<param><key>note</key><value>RX Magic</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>1</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>-1</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_1</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>addr=192.168.1.202</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>samp_freq</value></param>
<param><key>gain0</key><value>all_tx_gain</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>addr=192.168.1.200</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>samp_freq</value></param>
<param><key>gain0</key><value>all_tx_gain</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_float_to_complex_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_float_to_complex_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_1</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_0</source_block_id><sink_block_id>blocks_float_to_complex_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_0</source_block_id><sink_block_id>blocks_float_to_complex_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_1</source_block_id><sink_block_id>uhd_usrp_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
